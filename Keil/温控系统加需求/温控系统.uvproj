# Keil uVision project 温控系统.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 温控系统 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 温控.c delay.c LCD12864.c ds1302.c 18b20.c key.c
